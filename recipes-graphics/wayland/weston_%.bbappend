PACKAGECONFIG:append = " rdp"
